<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sync_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Secondary User Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bands</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cazac_len</value></param>
<param><key>value</key><value>71</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>chanmap</key><value>subchan_map</value></param>
<param><key>bits</key><value>256*8</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel</value></param>
<param><key>value</key><value>[h*np.exp(1j*2*np.pi*np.random.random()) for h in [0.98304252, 0.01179651, 0.00516097]]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>1120</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1280*2</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fir</value></param>
<param><key>value</key><value>np.conj(np.fft.ifft(np.fft.ifftshift(np.hstack((np.fft.fftshift(np.fft.fft(sync.get_zadoff_chu(64))), np.zeros(3*64))))))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>FO</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_off</value></param>
<param><key>block_id</key><value>fbmc_cazac_freq_sync_cc_0</value></param>
<param><key>function_name</key><value>get_fo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npackets</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlen_base</value></param>
<param><key>value</key><value>32*8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym()))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subchan_map</value></param>
<param><key>value</key><value>np.concatenate(([0,]*2, [1,]*124, [0,]*2))</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**12</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>1.0  *10**(-tx_att_db/20)</value></param>
<param><key>L</key><value>cazac_len</value></param>
<param><key>taps</key><value>phydyas_taps_time[1:]/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))  *10**(-tx_att_db/20)</value></param>
<param><key>order</key><value>2</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>guard</key><value>8</value></param>
<param><key>bits</key><value>256*8</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>pilot_A</key><value>1.0</value></param>
<param><key>pilot_carriers</key><value>range(8, 118, 12) + [119]</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_att_db</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>freq_off*samp_rate</value></param>
<param><key>label</key><value>FO</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>0.001</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>fo</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>492</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>sync.get_bps()</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>256</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>100000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>sync.get_bps()</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>range(256) + range(255, -1, -1)</value></param>
</block>
<block>
<key>fbmc_cazac_freq_sync_cc</key>
<param><key>id</key><value>fbmc_cazac_freq_sync_cc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>fft</key><value>sync.get_fft_len()</value></param>
<param><key>fft_sequences</key><value>sync.get_cazac_ffts()</value></param>
<param><key>frame_len</key><value>sync.get_frame_samps(True)</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_cazac_time_sync_cc</key>
<param><key>id</key><value>fbmc_cazac_time_sync_cc_0</value></param>
<param><key>fir_sequences</key><value>sync.get_fir_sequences()</value></param>
<param><key>frame_len</key><value>sync.get_frame_samps(True)</value></param>
<param><key>peak</key><value>247+cazac_len//2</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>threshold</key><value>0.8</value></param>
</block>
<block>
<key>fbmc_channel_equalizer_vcvc</key>
<param><key>id</key><value>fbmc_channel_equalizer_vcvc_0</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>pilot_amplitude</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>cfg.phydyas_frequency_taps(cfg.num_overlap_sym())</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
</block>
<block>
<key>fbmc_channel_estimator_vcvc</key>
<param><key>id</key><value>fbmc_channel_estimator_vcvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>pilot_amp</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>np.array(cfg.phydyas_frequency_taps(cfg.num_overlap_sym()))</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
</block>
<block>
<key>fbmc_sliding_fft_cvc</key>
<param><key>id</key><value>fbmc_sliding_fft_cvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
</block>
<block>
<key>fbmc_subchannel_deframer_vcb</key>
<param><key>id</key><value>fbmc_subchannel_deframer_vcb_0</value></param>
<param><key>order</key><value>sync.get_bps()</value></param>
<param><key>threshold</key><value>0.9</value></param>
<param><key>guard</key><value>sync.get_guard_bands()</value></param>
<param><key>bits</key><value>cfg.num_payload_bits()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>preamble</key><value>sync.get_preamble_symbols()</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>symbols</key><value>sync.get_syms_frame()</value></param>
</block>
<block>
<key>fbmc_subchannel_frame_generator_bvc</key>
<param><key>id</key><value>fbmc_subchannel_frame_generator_bvc_0</value></param>
<param><key>order</key><value>sync.get_bps()</value></param>
<param><key>guards</key><value>sync.get_guard_bands()</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>payload_bits</key><value>cfg.num_payload_bits()</value></param>
<param><key>pilot_amp</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>preamble_symbols</key><value>sync.get_preamble_symbols()</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
<param><key>padding</key><value>True</value></param>
</block>
<block>
<key>fbmc_tx_sdft_vcc</key>
<param><key>id</key><value>fbmc_tx_sdft_vcc_0</value></param>
<param><key>taps</key><value>phydyas_taps_time/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>channel</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>8129</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Frame"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>sync.get_frame_samps(True)</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.15</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>fbmc_cazac_time_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>fbmc_subchannel_frame_generator_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_cazac_freq_sync_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_cazac_freq_sync_cc_0</source_block_id><sink_block_id>fbmc_sliding_fft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_cazac_time_sync_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_cazac_time_sync_cc_0</source_block_id><sink_block_id>fbmc_cazac_freq_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_channel_equalizer_vcvc_0</source_block_id><sink_block_id>fbmc_subchannel_deframer_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_channel_estimator_vcvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc_sliding_fft_cvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_sliding_fft_cvc_0</source_block_id><sink_block_id>fbmc_channel_estimator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_subchannel_deframer_vcb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_subchannel_frame_generator_bvc_0</source_block_id><sink_block_id>fbmc_tx_sdft_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
