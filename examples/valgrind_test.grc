<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>valgrind</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>This flowgraph is used to 
make a valgrind profile 
of the receiver chain</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Secondary User Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bands</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cazac_len</value></param>
<param><key>value</key><value>71</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(sync.phydyas_impulse_taps())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subchan_map</value></param>
<param><key>value</key><value>np.concatenate(([0,]*2, [1,]*124, [0,]*2))</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**13</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>1.0</value></param>
<param><key>L</key><value>cazac_len</value></param>
<param><key>order</key><value>2</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>guard</key><value>3</value></param>
<param><key>bits</key><value>2048</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>pilot_A</key><value>1.0</value></param>
<param><key>pilot_carriers</key><value>range(8, 118, 12) + [119]</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>128</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>fbmc_channel_equalizer_vcvc</key>
<param><key>id</key><value>fbmc_channel_equalizer_vcvc_0</value></param>
<param><key>overlap</key><value>sync.get_overlap()</value></param>
<param><key>pilot_amplitude</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>sync.phydyas_frequency_taps()</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>sync.get_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
</block>
<block>
<key>fbmc_channel_estimator_vcvc</key>
<param><key>id</key><value>fbmc_channel_estimator_vcvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>sync.get_overlap()</value></param>
<param><key>pilot_amp</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>sync.phydyas_frequency_taps()</value></param>
<param><key>subcarriers</key><value>sync.get_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
</block>
<block>
<key>fbmc_sliding_fft_cvc</key>
<param><key>id</key><value>fbmc_sliding_fft_cvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>sync.get_overlap()</value></param>
<param><key>subcarriers</key><value>sync.get_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
<param><key>padding</key><value>True</value></param>
</block>
<block>
<key>fbmc_subchannel_deframer_vcb</key>
<param><key>id</key><value>fbmc_subchannel_deframer_vcb_0</value></param>
<param><key>order</key><value>sync.get_bps()</value></param>
<param><key>threshold</key><value>0.8</value></param>
<param><key>guard</key><value>2</value></param>
<param><key>bits</key><value>sync.get_payload_bits()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>preamble</key><value>sync.get_preamble_symbols()</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>sync.get_subcarriers()</value></param>
<param><key>symbols</key><value>sync.get_syms_frame()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>fbmc_sliding_fft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_channel_equalizer_vcvc_0</source_block_id><sink_block_id>fbmc_subchannel_deframer_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_channel_estimator_vcvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc_sliding_fft_cvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_sliding_fft_cvc_0</source_block_id><sink_block_id>fbmc_channel_estimator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_subchannel_deframer_vcb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
