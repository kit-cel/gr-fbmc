<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>valgrind</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Secondary User Transmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bands</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>chanmap</key><value>subchan_map</value></param>
<param><key>bits</key><value>npackets*packetlen_base*8</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npackets</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlen_base</value></param>
<param><key>value</key><value>32*8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym()))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subchan_map</value></param>
<param><key>value</key><value>np.concatenate(([0,]*2, [1,]*124, [0,]*2))</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**13</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>1.0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()-1</value></param>
<param><key>taps</key><value>phydyas_taps_time[1:]/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>pilot_A</key><value>1.0</value></param>
<param><key>pilot_carriers</key><value>range(2, cfg.num_total_subcarriers()-2, 10)</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>fbmc_channel_equalizer_vcvc</key>
<param><key>id</key><value>fbmc_channel_equalizer_vcvc_0</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>pilot_amplitude</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>cfg.phydyas_frequency_taps(cfg.num_overlap_sym())</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>fbmc_channel_estimator_vcvc</key>
<param><key>id</key><value>fbmc_channel_estimator_vcvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>pilot_amp</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>np.array(cfg.phydyas_frequency_taps(cfg.num_overlap_sym()))</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>fbmc_sliding_fft_cvc</key>
<param><key>id</key><value>fbmc_sliding_fft_cvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>fbmc_subchannel_deframer_vcb</key>
<param><key>id</key><value>fbmc_subchannel_deframer_vcb_0</value></param>
<param><key>threshold</key><value>0.8</value></param>
<param><key>guard</key><value>2</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>preamble</key><value>sync.get_preamble_symbols()</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>symbols</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>fbmc_sliding_fft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_channel_equalizer_vcvc_0</source_block_id><sink_block_id>fbmc_subchannel_deframer_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_channel_estimator_vcvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc_sliding_fft_cvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_sliding_fft_cvc_0</source_block_id><sink_block_id>fbmc_channel_estimator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_subchannel_deframer_vcb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
