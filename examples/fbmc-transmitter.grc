<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fbmc_transmitter</value></param>
<param><key>title</key><value>FBMC transmitter</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>output_oversampling</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>center_freq</value></param>
<param><key>value</key><value>2425e6</value></param>
<param><key>min</key><value>2424e6</value></param>
<param><key>max</key><value>2426e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>The values shown in the blocks' parameters are the default ones. The right ones configured in the FBMC configuration block are used during runtime.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>The damping is needed to avoid clipping!</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>output_damping_factor</value></param>
<param><key>label</key><value>Output damping factor</value></param>
<param><key>value</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from numpy import log2</value></param>
</block>
<block>
<key>variable_configuration</key>
<param><key>id</key><value>cfg_old</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>fbmc.fbmc_config()</value></param>
<param><key>M</key><value>32</value></param>
<param><key>K</key><value>22</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>mod</key><value>"QPSK"</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
<param><key>sample_rate</key><value>1</value></param>
</block>
<block>
<key>fbmc_polyphase_filterbank_vcvc</key>
<param><key>id</key><value>fbmc_polyphase_filterbank_vcvc_0_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>taps</key><value>cfg.prototype_taps()</value></param>
</block>
<block>
<key>fbmc_serial_to_parallel_cvc</key>
<param><key>id</key><value>fbmc_serial_to_parallel_cvc_0</value></param>
<param><key>len_in</key><value> cfg.num_used_subcarriers()</value></param>
<param><key>vlen_out</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>channel_map</key><value>cfg.channel_map()</value></param>
</block>
<block>
<key>fbmc_output_commutator_vcc</key>
<param><key>id</key><value>fbmc_output_commutator_vcc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_frame_generator_vcvc</key>
<param><key>id</key><value>fbmc_frame_generator_vcvc_0</value></param>
<param><key>sym_len</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>num_payload</key><value>cfg.num_payload_sym()</value></param>
<param><key>inverse</key><value>0</value></param>
<param><key>num_overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>num_sync</key><value>cfg.num_sync_sym()</value></param>
</block>
<block>
<key>fbmc_serialize_iq_vcvc</key>
<param><key>id</key><value>fbmc_serialize_iq_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_apply_betas_vcvc</key>
<param><key>id</key><value>fbmc_apply_betas_vcvc_1_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>inverse</key><value>0</value></param>
</block>
<block>
<key>fbmc_preamble_insertion_vcvc</key>
<param><key>id</key><value>fbmc_preamble_insertion_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_sym_frame()</value></param>
<param><key>preamble_sym</key><value>cfg.preamble_sym()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT of TX signal (baseband)</value></param>
<param><key>samp_rate</key><value>samp_rate*output_oversampling</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>cfg.num_total_subcarriers()*output_oversampling*2</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>tx_enable</value></param>
<param><key>label</key><value>TX enable</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>choices</key><value>[0.0,1.0]</value></param>
<param><key>labels</key><value>['off', 'on']</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>60</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/felixwunsch/src/gr-fbmc/examples/tx.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>4</value></param>
<param><key>num_samps</key><value> cfg.num_used_subcarriers()*cfg.num_payload_sym()</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>tx_enable/output_damping_factor</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_tx</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.6"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2425e6</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>J1</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>[3, 3, 2, 1, 0, 0, 0, 0, 0, 0, 0, 2, 3, 2, 1, 3, 1, 3, 0, 3, 3, 0, 2,3, 2, 1, 0, 0, 3, 2, 2, 0, 2, 1, 0, 2, 2, 0, 3, 0, 1, 0, 3, 0, 0, 2,3, 3, 2, 0, 1, 0, 3, 1, 3, 0, 0, 3, 3, 3, 3, 1, 2, 2, 0, 0, 3, 2, 3,2, 0, 3, 0, 1, 2, 2, 1, 0, 1, 2, 2, 0, 3, 0, 3, 3, 3, 3, 3, 2, 1, 2,0, 3, 0, 3, 1, 2, 2, 3, 1, 3, 3, 2, 0, 3, 2, 3, 2, 1, 1, 0, 2, 3, 3,0, 1, 1, 2, 1, 3, 3, 0, 1, 2, 1, 2, 0, 3, 2, 3, 1, 1, 0, 1, 2, 1, 1,0, 3, 1, 3, 2, 1, 1, 3, 0, 1, 3, 2, 0, 3, 1, 0, 1, 0, 3, 1, 2, 3, 1,3, 3, 0, 0, 1, 0, 3, 0, 0, 2, 3, 0, 1, 2, 1, 1, 3, 2, 1, 3, 2, 1, 2,2, 1, 2, 2, 1, 0, 2, 3]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cfg.constellation_points()</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>wav_source_b</key>
<param><key>id</key><value>wav_source_b_0</value></param>
<param><key>filename</key><value>"/home/felixwunsch/Music/thriller24.wav"</value></param>
<param><key>bps</key><value>2</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>M</key><value>34</value></param>
<param><key>K</key><value>22</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>mod</key><value>"QPSK"</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
</block>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>fbmc_serial_to_parallel_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_serial_to_parallel_cvc_0</source_block_id><sink_block_id>fbmc_frame_generator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_serialize_iq_vcvc_0</source_block_id><sink_block_id>fbmc_apply_betas_vcvc_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>fbmc_polyphase_filterbank_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_polyphase_filterbank_vcvc_0_0</source_block_id><sink_block_id>fbmc_output_commutator_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_output_commutator_vcc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_vcvc_0</source_block_id><sink_block_id>fbmc_serialize_iq_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_apply_betas_vcvc_1_0</source_block_id><sink_block_id>fbmc_preamble_insertion_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_preamble_insertion_vcvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wav_source_b_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
