<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps</value></param>
<param><key>value</key><value>cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>fbmc_polyphase_filterbank_vcvc</key>
<param><key>id</key><value>fbmc_polyphase_filterbank_vcvc_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>taps</key><value>cfg.prototype_taps()</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>np.arange(1, cfg.num_total_subcarriers() +1)</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_output_commutator_vcc</key>
<param><key>id</key><value>fbmc_output_commutator_vcc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>fbmc_tx_sdft_vcc</key>
<param><key>id</key><value>fbmc_tx_sdft_vcc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>taps</key><value>np.append(cfg.prototype_taps_float()[:-1], [0.0, ])</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>M</key><value>20</value></param>
<param><key>K</key><value>16</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>mod</key><value>"QPSK"</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>np.arange(1, 2 * cfg.num_total_subcarriers() +1)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>fbmc_rx_sdft_cvc</key>
<param><key>id</key><value>fbmc_rx_sdft_cvc_0</value></param>
<param><key>taps</key><value>phydyas_taps</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>fbmc_rx_polyphase_cvc</key>
<param><key>id</key><value>fbmc_rx_polyphase_cvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>taps</key><value>phydyas_taps</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_rx_domain_cvc</key>
<param><key>id</key><value>fbmc_rx_domain_cvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>taps</key><value>cfg.phydyas_frequency_taps(cfg.num_overlap_sym())</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>divval</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>2.0</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>30.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1.0/divval</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>color3</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label6</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>performance_stats</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>fbmc_polyphase_filterbank_vcvc_0_0</source_block_id><sink_block_id>fbmc_output_commutator_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>fbmc_polyphase_filterbank_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>fbmc_tx_sdft_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_output_commutator_vcc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_output_commutator_vcc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>fbmc_rx_polyphase_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>fbmc_rx_domain_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_domain_cvc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_polyphase_cvc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>fbmc_rx_sdft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_sdft_cvc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_sdft_cvc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
