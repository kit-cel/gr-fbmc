<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fbmc_transmitter</value></param>
<param><key>title</key><value>FBMC Transmitter</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>hier block for FBMC transmitter blocks</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>FBMC</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>[1, 0, 1, 0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>total_subcarriers</value></param>
<param><key>label</key><value>Num Total Subcarriers</value></param>
<param><key>value</key><value>32</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>used_subcarriers</value></param>
<param><key>label</key><value>Num Used Subcarriers</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_payload_symbols</value></param>
<param><key>label</key><value>Num Payload Symbols</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_overlap_symbols</value></param>
<param><key>label</key><value>Num Overlap Symbols</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_sync_symbols</value></param>
<param><key>label</key><value>Num Sync Symbols</value></param>
<param><key>value</key><value>8</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>label</key><value>Frame Length</value></param>
<param><key>value</key><value>28</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>channel_map</value></param>
<param><key>label</key><value>Channel Map Vector</value></param>
<param><key>value</key><value>[1, ] * 32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_symbol</value></param>
<param><key>label</key><value>Preamble Symbol</value></param>
<param><key>value</key><value>[1.0+1.0j, ] * 32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phydyas_taps</value></param>
<param><key>label</key><value>PHYDYAS taps</value></param>
<param><key>value</key><value>[1.0, ] * 32</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>complex_out</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>bit_input</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>fbmc_frame_generator_bvc</key>
<param><key>id</key><value>fbmc_frame_generator_bvc_0</value></param>
<param><key>used_subcarriers</key><value>used_subcarriers</value></param>
<param><key>total_subcarriers</key><value>total_subcarriers</value></param>
<param><key>payload_symbols</key><value>num_payload_symbols</value></param>
<param><key>overlap</key><value>num_overlap_symbols</value></param>
<param><key>channel_map</key><value>channel_map</value></param>
<param><key>preamble</key><value>preamble_symbol</value></param>
</block>
<block>
<key>fbmc_tx_sdft_vcc</key>
<param><key>id</key><value>fbmc_tx_sdft_vcc_0</value></param>
<param><key>taps</key><value>phydyas_taps</value></param>
<param><key>osr</key><value>total_subcarriers</value></param>
</block>
<block>
<key>fbmc_serialize_iq_vcvc</key>
<param><key>id</key><value>fbmc_serialize_iq_vcvc_tx</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>used_subcarriers</value></param>
</block>
<block>
<key>fbmc_preamble_insertion_vcvc</key>
<param><key>id</key><value>fbmc_preamble_insertion_vcvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>total_subcarriers</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>preamble_sym</key><value>preamble_symbol</value></param>
</block>
<block>
<key>fbmc_frame_generator_vcvc</key>
<param><key>id</key><value>fbmc_frame_generator_vcvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>sym_len</key><value>total_subcarriers</value></param>
<param><key>num_payload</key><value>num_payload_symbols</value></param>
<param><key>inverse</key><value>0</value></param>
<param><key>num_overlap</key><value>num_overlap_symbols</value></param>
<param><key>num_sync</key><value>num_sync_symbols</value></param>
</block>
<block>
<key>fbmc_apply_betas_vcvc</key>
<param><key>id</key><value>fbmc_apply_betas_vcvc_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>total_subcarriers</value></param>
<param><key>inverse</key><value>0</value></param>
</block>
<block>
<key>fbmc_serial_to_parallel_cvc</key>
<param><key>id</key><value>fbmc_serial_to_parallel_cvc_tx</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>len_in</key><value>used_subcarriers</value></param>
<param><key>vlen_out</key><value>total_subcarriers</value></param>
<param><key>channel_map</key><value>channel_map</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_tx</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>constellation</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>complex_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bit_input</source_block_id><sink_block_id>digital_chunks_to_symbols_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_preamble_insertion_vcvc_0</source_block_id><sink_block_id>fbmc_tx_sdft_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bit_input</source_block_id><sink_block_id>fbmc_frame_generator_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_bvc_0</source_block_id><sink_block_id>fbmc_tx_sdft_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_tx</source_block_id><sink_block_id>fbmc_serialize_iq_vcvc_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_serialize_iq_vcvc_tx</source_block_id><sink_block_id>fbmc_serial_to_parallel_cvc_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_vcvc_0</source_block_id><sink_block_id>fbmc_preamble_insertion_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_serial_to_parallel_cvc_tx</source_block_id><sink_block_id>fbmc_apply_betas_vcvc_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_apply_betas_vcvc_1_0</source_block_id><sink_block_id>fbmc_frame_generator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
