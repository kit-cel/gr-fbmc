<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fbmc_multichannel_receiver</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>category</key><value>FBMC</value></param>
<param><key>description</key><value>FBMC Multichannel Receiver with Sync</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FBMC Multichannel Receiver with Sync</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>bit_out</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/wunsch/src/dyspan15_5gssc/gr-dyspan/apps/postsync.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/wunsch/src/dyspan15_5gssc/gr-dyspan/apps/presync.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>num_overlap_symbols/2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>total_subcarriers * num_subchannels</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_avg_len</value></param>
<param><key>label</key><value>CFO MA length</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>channel_map</value></param>
<param><key>label</key><value>Channel Map Vector</value></param>
<param><key>value</key><value>[1, ] * 32</value></param>
</block>
<block>
<key>fbmc_multichannel_deframer_vcb</key>
<param><key>id</key><value>fbmc_multichannel_deframer_vcb_0</value></param>
<param><key>channel_map</key><value>channel_map</value></param>
<param><key>overlap</key><value>num_overlap_symbols</value></param>
<param><key>payload_bits</key><value>num_payload_bits</value></param>
<param><key>payload_symbols</key><value>num_payload_symbols</value></param>
<param><key>total_subcarriers</key><value>total_subcarriers</value></param>
<param><key>num_preamble_symbols</key><value>len(preamble)/total_subcarriers</value></param>
</block>
<block>
<key>fbmc_multichannel_frame_sync_cc</key>
<param><key>id</key><value>fbmc_multichannel_frame_sync_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>L</key><value>total_subcarriers * num_subchannels</value></param>
<param><key>preamble_sym</key><value>preamble</value></param>
<param><key>step_size</key><value>stepsize</value></param>
<param><key>nsym_frame</key><value>num_sym_frame</value></param>
<param><key>taps</key><value>phydyas_taps_time</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>fbmc_phase_sync_cc</key>
<param><key>id</key><value>fbmc_phase_sync_cc_0</value></param>
<param><key>L</key><value>total_subcarriers*num_subchannels</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>search_window</key><value>search_window_len</value></param>
<param><key>nsym_frame</key><value>num_sym_frame</value></param>
<param><key>taps</key><value>phydyas_taps_time</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>fbmc_rx_sdft_cvc</key>
<param><key>id</key><value>fbmc_rx_sdft_cvc_0</value></param>
<param><key>taps</key><value>phydyas_taps_time</value></param>
<param><key>osr</key><value>total_subcarriers * num_subchannels</value></param>
</block>
<block>
<key>fbmc_time_freq_sync_cc</key>
<param><key>id</key><value>fbmc_time_freq_sync_cc_0</value></param>
<param><key>addsamps</key><value>search_window_len</value></param>
<param><key>cfo_avg</key><value>cfo_avg_len</value></param>
<param><key>L</key><value>total_subcarriers*num_subchannels</value></param>
<param><key>nsym_frame</key><value>num_sym_frame</value></param>
<param><key>stepsize</key><value>stepsize</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_overlap_symbols</value></param>
<param><key>label</key><value>Num Overlap Symbols</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_payload_bits</value></param>
<param><key>label</key><value>Num Payload Bits</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_payload_symbols</value></param>
<param><key>label</key><value>Num Payload Symbols</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_subchannels</value></param>
<param><key>label</key><value>Num Subchannels</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_sym_frame</value></param>
<param><key>label</key><value>Num Symbols per Frame</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>label</key><value>PHYDYAS taps (time domain)</value></param>
<param><key>value</key><value>[1.0, ] * 32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>label</key><value>Preamble Symbol (freq domain)</value></param>
<param><key>value</key><value>[1.0+1.0j, ] * 32</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>rx_signal</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>search_window_len</value></param>
<param><key>label</key><value>Search window length</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stepsize</value></param>
<param><key>label</key><value>Step Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>total_subcarriers</value></param>
<param><key>label</key><value>Num Total Subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>fbmc_multichannel_deframer_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_multichannel_deframer_vcb_0</source_block_id><sink_block_id>bit_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_multichannel_frame_sync_cc_0</source_block_id><sink_block_id>fbmc_rx_sdft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_phase_sync_cc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_phase_sync_cc_0</source_block_id><sink_block_id>fbmc_rx_sdft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_sdft_cvc_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_time_freq_sync_cc_0</source_block_id><sink_block_id>fbmc_phase_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_signal</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_signal</source_block_id><sink_block_id>fbmc_multichannel_frame_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_signal</source_block_id><sink_block_id>fbmc_time_freq_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
