<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>perf_test_fg</value></param>
<param><key>title</key><value>Performance Test Transceiver Flowgraph</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zeros</value></param>
<param><key>value</key><value>np.zeros(cfg.num_total_subcarriers() * cfg.num_overlap_sym())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>myrange</value></param>
<param><key>value</key><value>np.arange(1, 4 * cfg.num_total_subcarriers() +1)</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>M</key><value>28</value></param>
<param><key>K</key><value>16</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>mod</key><value>"QPSK"</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>label</key><value>Noise voltage</value></param>
<param><key>value</key><value>1e-6</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>1.0</value></param>
<param><key>step</key><value>1e-3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>np.ones(cfg.num_total_subcarriers(), dtype=int)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>[100, ] * cfg.num_total_subcarriers()</value></param>
<param><key>vlen</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1,1,2</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>4</value></param>
<param><key>vlen</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-0.5</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>3,0,2,5</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>fbmc_tx_sdft_vcc</key>
<param><key>id</key><value>fbmc_tx_sdft_vcc_0</value></param>
<param><key>taps</key><value>cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym())</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_rx_sdft_cvc</key>
<param><key>id</key><value>fbmc_rx_sdft_cvc_0</value></param>
<param><key>taps</key><value>cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym())</value></param>
<param><key>osr</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>fbmc_deframer_vcb</key>
<param><key>id</key><value>fbmc_deframer_vcb_0</value></param>
<param><key>used_subcarriers</key><value>cfg.num_used_subcarriers()</value></param>
<param><key>total_subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>num_preamble_symbols</key><value>4</value></param>
<param><key>payload_symbols</key><value>cfg.num_payload_sym()</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>channel_map</key><value>cfg.channel_map()</value></param>
</block>
<block>
<key>fbmc_frame_generator_bvc</key>
<param><key>id</key><value>fbmc_frame_generator_bvc_0</value></param>
<param><key>used_subcarriers</key><value>cfg.num_used_subcarriers()</value></param>
<param><key>total_subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>payload_symbols</key><value>cfg.num_payload_sym()</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>channel_map</key><value>cfg.channel_map()</value></param>
<param><key>preamble</key><value>cfg.preamble_sym()</value></param>
</block>
<connection><source_block_id>fbmc_frame_generator_bvc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>fbmc_frame_generator_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_bvc_0</source_block_id><sink_block_id>fbmc_tx_sdft_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_deframer_vcb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc_deframer_vcb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>fbmc_deframer_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_sdft_cvc_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>fbmc_rx_sdft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
