<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_usrp_test</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bands</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>chanmap</key><value>subchan_map</value></param>
<param><key>bits</key><value>npackets*packetlen_base*8</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npackets</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packetlen_base</value></param>
<param><key>value</key><value>32*4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(cfg.phydyas_impulse_taps(cfg.num_total_subcarriers(), cfg.num_overlap_sym()))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subchan_map</value></param>
<param><key>value</key><value>np.concatenate(([0,]*2, [1,]*60, [0,]*2))</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**13</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>1.0  *10**(-tx_att_db/20)</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()-1</value></param>
<param><key>taps</key><value>phydyas_taps_time[1:]/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))  *10**(-tx_att_db/20)</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>pilot_A</key><value>1.0</value></param>
<param><key>pilot_carriers</key><value>range(2, cfg.num_total_subcarriers()-2, 10)</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_att_db</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>6</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>fbmc_channel_equalizer_vcvc</key>
<param><key>id</key><value>fbmc_channel_equalizer_vcvc_0</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>pilot_amplitude</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>cfg.phydyas_frequency_taps(cfg.num_overlap_sym())</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>fbmc_channel_estimator_vcvc</key>
<param><key>id</key><value>fbmc_channel_estimator_vcvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>pilot_amp</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>taps</key><value>np.array(cfg.phydyas_frequency_taps(cfg.num_overlap_sym()))</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>fbmc_sliding_fft_cvc</key>
<param><key>id</key><value>fbmc_sliding_fft_cvc_0</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>fbmc_subchannel_deframer_vcb</key>
<param><key>id</key><value>fbmc_subchannel_deframer_vcb_0</value></param>
<param><key>threshold</key><value>0.9</value></param>
<param><key>guard</key><value>2</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>preamble</key><value>sync.get_preamble_symbols()</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>subcarriers</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>symbols</key><value>cfg.num_payload_bits() / (cfg.num_total_subcarriers() - len(sync.get_pilot_carriers())/sync.get_pilot_timestep()) + 1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_ddc</key>
<param><key>id</key><value>uhd_rfnoc_streamer_ddc_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fpga_module_name</key><value>noc_block_ddc</value></param>
<param><key>freq</key><value>0.0</value></param>
<param><key>fullscale</key><value>1.0</value></param>
<param><key>input_rate</key><value>200e6</value></param>
<param><key>num_chans</key><value>1</value></param>
<param><key>output_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_dma_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_dma_fifo_0</value></param>
<param><key>base_addr_0</key><value>0</value></param>
<param><key>base_addr_1</key><value>33554432</value></param>
<param><key>depth_0</key><value>33554432</value></param>
<param><key>depth_1</key><value>33554432</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_dma_fifo</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>num_chans</key><value>1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>ant</key><value>"TX/RX"</value></param>
<param><key>freq</key><value>1.982e9</value></param>
<param><key>dcenable</key><value>True</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>rate</key><value>1e6</value></param>
<param><key>stream_args</key><value>spp=256</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>2.45e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"name=Denise"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>fbmc_channel_equalizer_vcvc_0</source_block_id><sink_block_id>fbmc_subchannel_deframer_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_channel_estimator_vcvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fbmc_channel_estimator_vcvc_0</source_block_id><sink_block_id>fbmc_channel_equalizer_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_sliding_fft_cvc_0</source_block_id><sink_block_id>fbmc_channel_estimator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_subchannel_deframer_vcb_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_ddc_0</source_block_id><sink_block_id>fbmc_sliding_fft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_dma_fifo_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_ddc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_dma_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>fbmc_sliding_fft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
