<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fbmc_receiver</value></param>
<param><key>title</key><value>FBMC receiver</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_oversampling</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>The values shown in the blocks' parameters are the default ones. The right ones configured in the FBMC configuration block are used during runtime.</value></param>
</block>
<block>
<key>fbmc_frame_generator_vcvc</key>
<param><key>id</key><value>fbmc_frame_generator_vcvc_1</value></param>
<param><key>sym_len</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>num_payload</key><value>cfg.num_payload_sym()</value></param>
<param><key>inverse</key><value>1</value></param>
<param><key>num_overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>num_sync</key><value>cfg.num_sync_sym()</value></param>
</block>
<block>
<key>fbmc_combine_iq_vcvc</key>
<param><key>id</key><value>fbmc_combine_iq_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>80</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>fbmc_input_commutator_cvc</key>
<param><key>id</key><value>fbmc_input_commutator_cvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_polyphase_filterbank_vcvc</key>
<param><key>id</key><value>fbmc_polyphase_filterbank_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>taps</key><value>cfg.prototype_taps()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.4"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant0</key><value>J1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>man_freq_corr</value></param>
<param><key>label</key><value>man_freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-20e3</value></param>
<param><key>max</key><value>20e3</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>man_freq_corr</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['spectrum','constellation']</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT of RX signal (baseband)</value></param>
<param><key>samp_rate</key><value>samp_rate*input_oversampling</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>cfg.num_total_subcarriers()*input_oversampling*2</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>constellation</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RX constellation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>fbmc_parallel_to_serial_vcc</key>
<param><key>id</key><value>fbmc_parallel_to_serial_vcc_0</value></param>
<param><key>len_out</key><value>cfg.num_used_subcarriers()</value></param>
<param><key>vlen_in</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>channel_map</key><value>cfg.channel_map()</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/felixwunsch/src/gr-fbmc/examples/rx.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>center_freq</value></param>
<param><key>value</key><value>2425e6</value></param>
<param><key>min</key><value>2424e6</value></param>
<param><key>max</key><value>2526e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>fbmc_frame_sync_cc</key>
<param><key>id</key><value>fbmc_frame_sync_cc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_sym_frame()</value></param>
<param><key>preamble_sym</key><value>cfg.time_domain_preamble_sym()</value></param>
<param><key>step_size</key><value>max(cfg.num_total_subcarriers()/10,1)</value></param>
<param><key>threshold</key><value>0.8</value></param>
</block>
<block>
<key>fbmc_apply_betas_vcvc</key>
<param><key>id</key><value>fbmc_apply_betas_vcvc_1</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>inverse</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from numpy import log2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>fbmc_symbols_to_bits_cb</key>
<param><key>id</key><value>fbmc_symbols_to_bits_cb_0</value></param>
<param><key>constellation</key><value>cfg.constellation()</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>[3, 3, 2, 1, 0, 0, 0, 0, 0, 0, 0, 2, 3, 2, 1, 3, 1, 3, 0, 3, 3, 0, 2,3, 2, 1, 0, 0, 3, 2, 2, 0, 2, 1, 0, 2, 2, 0, 3, 0, 1, 0, 3, 0, 0, 2,3, 3, 2, 0, 1, 0, 3, 1, 3, 0, 0, 3, 3, 3, 3, 1, 2, 2, 0, 0, 3, 2, 3,2, 0, 3, 0, 1, 2, 2, 1, 0, 1, 2, 2, 0, 3, 0, 3, 3, 3, 3, 3, 2, 1, 2,0, 3, 0, 3, 1, 2, 2, 3, 1, 3, 3, 2, 0, 3, 2, 3, 2, 1, 1, 0, 2, 3, 3,0, 1, 1, 2, 1, 3, 3, 0, 1, 2, 1, 2, 0, 3, 2, 3, 1, 1, 0, 1, 2, 1, 1,0, 3, 1, 3, 2, 1, 1, 3, 0, 1, 3, 2, 0, 3, 1, 0, 1, 0, 3, 1, 2, 3, 1,3, 3, 0, 0, 1, 0, 3, 0, 0, 2, 3, 0, 1, 2, 1, 1, 3, 2, 1, 3, 2, 1, 2,2, 1, 2, 2, 1, 0, 2, 3]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>BER</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>1</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>wav_sink_b</key>
<param><key>id</key><value>wav_sink_b_0</value></param>
<param><key>filename</key><value>"/home/felixwunsch/rx_out.wav"</value></param>
<param><key>bps</key><value>2</value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>M</key><value>34</value></param>
<param><key>K</key><value>22</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>mod</key><value>"QPSK"</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
</block>
<connection><source_block_id>fbmc_apply_betas_vcvc_1</source_block_id><sink_block_id>fbmc_combine_iq_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_combine_iq_vcvc_0</source_block_id><sink_block_id>fbmc_frame_generator_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_vcvc_1</source_block_id><sink_block_id>fbmc_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_parallel_to_serial_vcc_0</source_block_id><sink_block_id>fbmc_symbols_to_bits_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_parallel_to_serial_vcc_0</source_block_id><sink_block_id>constellation</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_symbols_to_bits_cb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_polyphase_filterbank_vcvc_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>fbmc_apply_betas_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_input_commutator_cvc_0</source_block_id><sink_block_id>fbmc_polyphase_filterbank_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_sync_cc_0</source_block_id><sink_block_id>fbmc_input_commutator_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_parallel_to_serial_vcc_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>fbmc_frame_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_symbols_to_bits_cb_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_symbols_to_bits_cb_0</source_block_id><sink_block_id>wav_sink_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
