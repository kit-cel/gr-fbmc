<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_tx</value></param>
<param><key>comment</key><value>Transmitter for the system</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bands</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cazac_len</value></param>
<param><key>value</key><value>127</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>value</key><value>np.array(sync.phydyas_impulse_taps())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable_sync_config</key>
<param><key>id</key><value>sync</value></param>
<param><key>fft_len</key><value>2**13</value></param>
<param><key>pos</key><value>4</value></param>
<param><key>A</key><value>1.0  *10**(-tx_att_db/20)</value></param>
<param><key>L</key><value>cazac_len</value></param>
<param><key>order</key><value>2</value></param>
<param><key>bands</key><value>bands</value></param>
<param><key>guard</key><value>8</value></param>
<param><key>bits</key><value>256*8</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>pilot_A</key><value>1.0</value></param>
<param><key>pilot_carriers</key><value>range(8, 118, 12) + [119]</value></param>
<param><key>pilot_timestep</key><value>4</value></param>
<param><key>N</key><value>128</value></param>
<param><key>q</key><value>4</value></param>
<param><key>u</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_att_db</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>2048</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/senpo/Desktop/fbmc_cazac.c32</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>sync.get_bps()</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[1]*384+[2]*384+[3]*384</value></param>
</block>
<block>
<key>fbmc_subchannel_frame_generator_bvc</key>
<param><key>id</key><value>fbmc_subchannel_frame_generator_bvc_0</value></param>
<param><key>order</key><value>sync.get_bps()</value></param>
<param><key>guards</key><value>8</value></param>
<param><key>overlap</key><value>sync.get_overlap()</value></param>
<param><key>payload_bits</key><value>sync.get_payload_bits()</value></param>
<param><key>pilot_amp</key><value>sync.get_pilot_amplitude()</value></param>
<param><key>pilot_timestep</key><value>sync.get_pilot_timestep()</value></param>
<param><key>pilot_carriers</key><value>sync.get_pilot_carriers()</value></param>
<param><key>preamble_symbols</key><value>sync.get_preamble_symbols()</value></param>
<param><key>subcarriers</key><value>sync.get_subcarriers()</value></param>
<param><key>frame_len</key><value>sync.get_syms_frame()</value></param>
<param><key>padding</key><value>True</value></param>
</block>
<block>
<key>fbmc_tx_sdft_vcc</key>
<param><key>id</key><value>fbmc_tx_sdft_vcc_0</value></param>
<param><key>taps</key><value>phydyas_taps_time/np.sqrt(phydyas_taps_time.dot(phydyas_taps_time))/4</value></param>
<param><key>osr</key><value>sync.get_subcarriers()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>sync.get_frame_samps(True)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>2.49e9</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>fbmc_subchannel_frame_generator_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_subchannel_frame_generator_bvc_0</source_block_id><sink_block_id>fbmc_tx_sdft_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_tx_sdft_vcc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
