<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fbmc_transceiver_ota</value></param>
<param><key>title</key><value>FBMC Transceiver OTA</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>description</key><value>OTA BER measurement</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>output_oversampling</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>BER</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>1</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>1000</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>fbmc_serialize_iq_vcvc</key>
<param><key>id</key><value>fbmc_serialize_iq_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_input_commutator_cvc</key>
<param><key>id</key><value>fbmc_input_commutator_cvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>fbmc_symbols_to_bits_cb</key>
<param><key>id</key><value>fbmc_symbols_to_bits_cb_0</value></param>
<param><key>constellation</key><value>cfg.constellation()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>fbmc_apply_betas_vcvc</key>
<param><key>id</key><value>fbmc_apply_betas_vcvc_1_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>inverse</key><value>0</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cfg.constellation_points()</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>fbmc_polyphase_filterbank_vcvc</key>
<param><key>id</key><value>fbmc_polyphase_filterbank_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>taps</key><value>cfg.prototype_taps()</value></param>
</block>
<block>
<key>fbmc_polyphase_filterbank_vcvc</key>
<param><key>id</key><value>fbmc_polyphase_filterbank_vcvc_0_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>taps</key><value>cfg.prototype_taps()</value></param>
</block>
<block>
<key>fbmc_frame_generator_vcvc</key>
<param><key>id</key><value>fbmc_frame_generator_vcvc_1</value></param>
<param><key>sym_len</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>num_payload</key><value>cfg.num_payload_sym()</value></param>
<param><key>inverse</key><value>1</value></param>
<param><key>num_overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>num_sync</key><value>cfg.num_sync_sym()</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>rx_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>tx_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>tx_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>rx_out</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>1000</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from numpy import exp</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>The values shown in the blocks' parameters are the default ones. The right ones configured in the FBMC configuration block are used during runtime.</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>fbmc_frame_generator_vcvc</key>
<param><key>id</key><value>fbmc_frame_generator_vcvc_0</value></param>
<param><key>sym_len</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>num_payload</key><value>cfg.num_payload_sym()</value></param>
<param><key>inverse</key><value>0</value></param>
<param><key>num_overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>num_sync</key><value>cfg.num_sync_sym()</value></param>
</block>
<block>
<key>fbmc_preamble_insertion_vcvc</key>
<param><key>id</key><value>fbmc_preamble_insertion_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_sym_frame()</value></param>
<param><key>type</key><value>"IAM"</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/felixwunsch/src/stuff/rx_out.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/felixwunsch/src/stuff/tx_in.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>fbmc_output_commutator_vcc</key>
<param><key>id</key><value>fbmc_output_commutator_vcc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>tx_signal</value></param>
</block>
<block>
<key>fbmc_combine_iq_vcvc</key>
<param><key>id</key><value>fbmc_combine_iq_vcvc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>man_freq_corr</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>center_freq</value></param>
<param><key>value</key><value>2425e6</value></param>
<param><key>min</key><value>2424e6</value></param>
<param><key>max</key><value>2426e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>output_oversampling</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>output_oversampling</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>after sync</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>(0,1,1,1)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>4</value></param>
<param><key>num_samps</key><value> cfg.num_used_subcarriers()*cfg.num_payload_sym()</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>output_damping_factor</value></param>
<param><key>label</key><value>Output damping factor</value></param>
<param><key>value</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>cfg.num_total_subcarriers()*10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>before sync</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>(0,0,1,1)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1.0/output_damping_factor</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>man_freq_corr</value></param>
<param><key>label</key><value>man_freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-20e3</value></param>
<param><key>max</key><value>20e3</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>The damping is needed to avoid clipping!</value></param>
</block>
<block>
<key>fbmc_apply_betas_vcvc</key>
<param><key>id</key><value>fbmc_apply_betas_vcvc_1</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>inverse</key><value>1</value></param>
</block>
<block>
<key>variable_configuration</key>
<param><key>id</key><value>cfg_old</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>fbmc.fbmc_config()</value></param>
<param><key>M</key><value>32</value></param>
<param><key>K</key><value>22222</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>mod</key><value>"QPSK"</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>tx signal</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>(1,1,1,1)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>fbmc_parallel_to_serial_vcc</key>
<param><key>id</key><value>fbmc_parallel_to_serial_vcc_0</value></param>
<param><key>len_out</key><value> cfg.num_used_subcarriers()</value></param>
<param><key>vlen_in</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>channel_map</key><value>cfg.channel_map()</value></param>
</block>
<block>
<key>fbmc_serial_to_parallel_cvc</key>
<param><key>id</key><value>fbmc_serial_to_parallel_cvc_0</value></param>
<param><key>len_in</key><value> cfg.num_used_subcarriers()</value></param>
<param><key>vlen_out</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>channel_map</key><value>cfg.channel_map()</value></param>
</block>
<block>
<key>fbmc_frame_sync_cc</key>
<param><key>id</key><value>fbmc_frame_sync_cc_0</value></param>
<param><key>L</key><value>cfg.num_total_subcarriers()</value></param>
<param><key>frame_len</key><value>cfg.num_sym_frame()</value></param>
<param><key>overlap</key><value>cfg.num_overlap_sym()</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
<param><key>step_size</key><value>1</value></param>
<param><key>threshold</key><value>0.9</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_tx</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.5"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant0</key><value>J1</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>variable_configuration_new</key>
<param><key>id</key><value>cfg</value></param>
<param><key>M</key><value>33</value></param>
<param><key>K</key><value>222</value></param>
<param><key>overlap</key><value>4</value></param>
<param><key>mod</key><value>"QPSK"</value></param>
<param><key>preamble</key><value>"IAM"</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>60</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_rx</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.4"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant0</key><value>J1</value></param>
</block>
<connection><source_block_id>fbmc_symbols_to_bits_cb_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_parallel_to_serial_vcc_0</source_block_id><sink_block_id>fbmc_symbols_to_bits_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_combine_iq_vcvc_0</source_block_id><sink_block_id>fbmc_frame_generator_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_vcvc_1</source_block_id><sink_block_id>fbmc_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_sync_cc_0</source_block_id><sink_block_id>fbmc_input_commutator_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_input_commutator_cvc_0</source_block_id><sink_block_id>fbmc_polyphase_filterbank_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>fbmc_apply_betas_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_polyphase_filterbank_vcvc_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_apply_betas_vcvc_1</source_block_id><sink_block_id>fbmc_combine_iq_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_serial_to_parallel_cvc_0</source_block_id><sink_block_id>fbmc_frame_generator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>fbmc_serial_to_parallel_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_preamble_insertion_vcvc_0</source_block_id><sink_block_id>fbmc_serialize_iq_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_vcvc_0</source_block_id><sink_block_id>fbmc_preamble_insertion_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_serialize_iq_vcvc_0</source_block_id><sink_block_id>fbmc_apply_betas_vcvc_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_apply_betas_vcvc_1_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>fbmc_polyphase_filterbank_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_output_commutator_vcc_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_polyphase_filterbank_vcvc_0_0</source_block_id><sink_block_id>fbmc_output_commutator_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_output_commutator_vcc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_rx</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>fbmc_frame_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_sync_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_sync_cc_0</source_block_id><sink_block_id>wxgui_fftsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
