<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fbmc_receiver</value></param>
<param><key>title</key><value>FBMC Receiver</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>description</key><value>FBMC Receiver hier blocks</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>FBMC</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>label</key><value>Constellation</value></param>
<param><key>value</key><value>[1, 0, 1, 0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>used_subcarriers</value></param>
<param><key>label</key><value>Num Used Subcarriers</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>total_subcarriers</value></param>
<param><key>label</key><value>Num Total Subcarriers</value></param>
<param><key>value</key><value>32</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>channel_map</value></param>
<param><key>label</key><value>Channel Map Vector</value></param>
<param><key>value</key><value>[1, ] * 32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_overlap_symbols</value></param>
<param><key>label</key><value>Num Overlap Symbols</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_payload_symbols</value></param>
<param><key>label</key><value>Num Payload Symbols</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_sync_symbols</value></param>
<param><key>label</key><value>Num Sync Symbols</value></param>
<param><key>value</key><value>8</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>label</key><value>Frame Length</value></param>
<param><key>value</key><value>28</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phydyas_taps_time</value></param>
<param><key>label</key><value>PHYDYAS taps (time domain)</value></param>
<param><key>value</key><value>[1.0, ] * 32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_symbol</value></param>
<param><key>label</key><value>Preamble Symbol (time domain)</value></param>
<param><key>value</key><value>[1.0+1.0j, ] * 32</value></param>
</block>
<block>
<key>fbmc_coarse_cfo_correction</key>
<param><key>id</key><value>fbmc_coarse_cfo_correction_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>channel_map</key><value>channel_map</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phydyas_taps_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>PHYDYAS taps (frequency domain)</value></param>
<param><key>value</key><value>[1.0, ] * 7</value></param>
</block>
<block>
<key>fbmc_rx_domain_cvc</key>
<param><key>id</key><value>fbmc_rx_domain_cvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>taps</key><value>phydyas_taps_freq</value></param>
<param><key>osr</key><value>total_subcarriers</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>freq_smt_out</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Freq Domain SMT out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>8</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>fbmc_rx_polyphase_cvc</key>
<param><key>id</key><value>fbmc_rx_polyphase_cvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>taps</key><value>phydyas_taps_time</value></param>
<param><key>osr</key><value>total_subcarriers</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>freq_smt_out_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Polyphase SMT out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>fbmc_apply_betas_vcvc</key>
<param><key>id</key><value>fbmc_apply_betas_vcvc_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>total_subcarriers</value></param>
<param><key>inverse</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>constellation_out_opt</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>constellation out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>fbmc_symbols_to_bits_cb</key>
<param><key>id</key><value>fbmc_symbols_to_bits_cb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>constellation</key><value>constellation</value></param>
</block>
<block>
<key>fbmc_combine_iq_vcvc</key>
<param><key>id</key><value>fbmc_combine_iq_vcvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>used_subcarriers</value></param>
</block>
<block>
<key>fbmc_simple_frame_generator_vcvc</key>
<param><key>id</key><value>fbmc_simple_frame_generator_vcvc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>sym_len</key><value>total_subcarriers</value></param>
<param><key>num_payload</key><value>num_payload_symbols</value></param>
<param><key>inverse</key><value>1</value></param>
<param><key>num_overlap</key><value>num_overlap_symbols</value></param>
<param><key>num_sync</key><value>num_sync_symbols</value></param>
</block>
<block>
<key>fbmc_parallel_to_serial_vcc</key>
<param><key>id</key><value>fbmc_parallel_to_serial_vcc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>len_out</key><value>used_subcarriers</value></param>
<param><key>vlen_in</key><value>total_subcarriers</value></param>
<param><key>channel_map</key><value>channel_map</value></param>
</block>
<block>
<key>fbmc_frame_generator_vcvc</key>
<param><key>id</key><value>fbmc_frame_generator_vcvc_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>sym_len</key><value>total_subcarriers</value></param>
<param><key>num_payload</key><value>num_payload_symbols</value></param>
<param><key>inverse</key><value>1</value></param>
<param><key>num_overlap</key><value>num_overlap_symbols</value></param>
<param><key>num_sync</key><value>num_sync_symbols</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>bit_out</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>6</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>rx_signal</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fbmc_frame_sync_cc</key>
<param><key>id</key><value>fbmc_frame_sync_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>L</key><value>total_subcarriers</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>preamble_sym</key><value>preamble_symbol</value></param>
<param><key>step_size</key><value>max(total_subcarriers/10,1)</value></param>
<param><key>threshold</key><value>0.95</value></param>
<param><key>overlap</key><value>num_overlap_symbols</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>freq_smt_out_0</value></param>
<param><key>label</key><value>SDFT SMT out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>fbmc_rx_sdft_cvc</key>
<param><key>id</key><value>fbmc_rx_sdft_cvc_0</value></param>
<param><key>taps</key><value>phydyas_taps_time</value></param>
<param><key>osr</key><value>total_subcarriers</value></param>
</block>
<block>
<key>fbmc_deframer_vcb</key>
<param><key>id</key><value>fbmc_deframer_vcb_0</value></param>
<param><key>used_subcarriers</key><value>used_subcarriers</value></param>
<param><key>total_subcarriers</key><value>total_subcarriers</value></param>
<param><key>num_preamble_symbols</key><value>int(len(preamble_symbol) // total_subcarriers)</value></param>
<param><key>payload_symbols</key><value>num_payload_symbols</value></param>
<param><key>overlap</key><value>num_overlap_symbols</value></param>
<param><key>channel_map</key><value>channel_map</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>num_overlap_symbols/2</value></param>
<param><key>vlen</key><value>total_subcarriers</value></param>
</block>
<connection><source_block_id>fbmc_coarse_cfo_correction_0</source_block_id><sink_block_id>fbmc_frame_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_sync_cc_0</source_block_id><sink_block_id>fbmc_rx_domain_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_signal</source_block_id><sink_block_id>fbmc_coarse_cfo_correction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_signal</source_block_id><sink_block_id>fbmc_frame_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_sync_cc_0</source_block_id><sink_block_id>fbmc_rx_sdft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_sdft_cvc_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_sync_cc_0</source_block_id><sink_block_id>fbmc_rx_polyphase_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_symbols_to_bits_cb_0</source_block_id><sink_block_id>bit_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_deframer_vcb_0</source_block_id><sink_block_id>bit_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>freq_smt_out_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_domain_cvc_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>freq_smt_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_polyphase_cvc_0</source_block_id><sink_block_id>freq_smt_out_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_polyphase_cvc_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_rx_sdft_cvc_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>freq_smt_out_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>fbmc_apply_betas_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>fbmc_deframer_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_combine_iq_vcvc_0</source_block_id><sink_block_id>constellation_out_opt</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_parallel_to_serial_vcc_0</source_block_id><sink_block_id>fbmc_combine_iq_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_frame_generator_vcvc_1</source_block_id><sink_block_id>fbmc_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_combine_iq_vcvc_0</source_block_id><sink_block_id>fbmc_symbols_to_bits_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_apply_betas_vcvc_1</source_block_id><sink_block_id>fbmc_frame_generator_vcvc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_apply_betas_vcvc_1</source_block_id><sink_block_id>fbmc_simple_frame_generator_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fbmc_simple_frame_generator_vcvc_0</source_block_id><sink_block_id>fbmc_parallel_to_serial_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_signal</source_block_id><sink_block_id>fbmc_rx_sdft_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
